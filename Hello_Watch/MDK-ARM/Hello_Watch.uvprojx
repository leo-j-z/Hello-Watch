# Keil uVision project Hello_Watch.uvprojx, settings and files
target Hello_Watch (5060528::V5.06 update 5 (build 528)::.\ARMCC)
  device: STM32F411CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.0
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: Hello_Watch +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F411xE
  c misc: --locale=english
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;..\SYSTEM;..\BSP\AHT21;..\BSP\BL24C02;..\BSP\EM7028;..\BSP\IIC;..\BSP\KEY;..\BSP\KT6328;..\BSP\LCD;..\BSP\LSM303DLH;..\BSP\MPU6050;..\BSP\OWDG;..\BSP\POWER;..\BSP\SPL06_001;..\BSP\TOUCH;..\Middlewares\LVGL\GUI\lvgl;..\Middlewares\LVGL\GUI\lvgl\src;..\Middlewares\LVGL\GUI\lvgl;..\Middlewares\LVGL\GUI\porting;..\Middlewares\LVGL\GUI\lvgl;..\User\Func\Inc;..\User\Tasks\Inc;..\User\GUI_APP;..\User\GUI_APP\screens\Inc;..\BSP\MPU6050\eMPL;..\Middlewares\LVGL\GUI;..\User
  asm include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x74000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Application/MDK-ARM
    ./: startup_stm32f411xe.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c adc.c dma.c rtc.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_ll_adc.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Application/User/System
    ../SYSTEM/: delay.c
  group Application/User/Tasks
    ../Middlewares/LVGL/GUI/porting/: lv_port_indev.c
    ../User/Tasks/Src/: user_ChargCheckTask.c user_DataSaveTask.c user_HardwareInitTask.c user_KeyTask.c user_MessageSendTask.c user_RunModeTasks.c user_ScrRenewTask.c user_SensUpdateTask.c user_TasksInit.c
  group Application/User/MidFunc
    ../User/Func/Src/: HWDataAccess.c PageManager.c StrCalculate.c
  group Application/User/GUI_APP
    ../User/GUI_APP/screens/Src/: ui_AboutPage.c ui_CalendarPage.c ui_ChargPage.c ui_CompassPage.c ui_ComputerPage.c ui_DateTimeSetPage.c ui_EnvPage.c ui_Game2048Page.c ui_GameMemPage.c ui_GameSelectPage.c ui_HomePage.c ui_HRPage.c ui_Megboxes.c ui_MenuPage.c ui_NFCCardPage.c ui_OffTimePage.c ui_SetPage.c ui_SPO2Page.c ui_TimerPage.c
    ../User/GUI_APP/: ui_helpers.c ui.c
  group Application/User/GUI_FONT_IMG
    ../User/GUI_APP/fonts/: ui_font_CuYuan.c ui_font_Cuyuan18.c ui_font_Cuyuan20.c ui_font_Cuyuan24.c ui_font_Cuyuan30.c ui_font_Cuyuan38.c ui_font_Cuyuan48.c ui_font_Cuyuan80.c ui_font_Cuyuan100.c ui_font_fonticonfont34.c ui_font_iconfont16.c ui_font_iconfont24.c ui_font_iconfont28.c ui_font_iconfont30.c ui_font_iconfont32.c ui_font_iconfont34.c ui_font_iconfont45.c ui_font_lvfontmontserrat20.c ui_font_uifontCuyuan48.c ui_font_iconfont31.c ui_font_iconfont25.c ui_font_iconfont29.c ui_font_iconfont33.c ui_font_Cuyuan21.c
    ../User/GUI_APP/IMGs/: ui_img_compass_needle_png.c
  group Drivers/User/BSP
    ../BSP/IIC/: iic_hal.c
    ../BSP/TOUCH/: CST816.c
    ../BSP/OWDG/: WODG.c
    ../BSP/AHT21/: AHT21.c
    ../BSP/BL24C02/: BL24C02.c DataSave.c
    ../BSP/EM7028/: em70x8.c HrAlgorythm.c user_Queue.c
    ../BSP/KEY/: key.c
    ../BSP/KT6328/: KT6328.c
    ../BSP/LCD/: lcd.c lcd_init.c
    ../BSP/LSM303DLH/: LSM303.c
    ../BSP/MPU6050/: mpu6050.c
    ../BSP/MPU6050/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ../BSP/SPL06_001/: SPL06_001.c
    ../BSP/POWER/: power.c
  group Middlewares/LVGL/GUI
    ../Middlewares/LVGL/GUI/lvgl/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
    ../Middlewares/LVGL/GUI/lvgl/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ../Middlewares/LVGL/GUI/lvgl/src/extra/: lv_extra.c
    ../Middlewares/LVGL/GUI/lvgl/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../Middlewares/LVGL/GUI/lvgl/src/extra/widgets/spinner/: lv_spinner.c
    ../Middlewares/LVGL/GUI/lvgl/src/extra/themes/default/: lv_theme_default.c
    ../Middlewares/LVGL/GUI/lvgl/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
    ../Middlewares/LVGL/GUI/lvgl/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_textarea.c lv_table.c
    ../Middlewares/LVGL/GUI/lvgl/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ../Middlewares/LVGL/GUI/lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
    ../Middlewares/LVGL/GUI/lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c
    ../Middlewares/LVGL/GUI/lvgl/src/extra/widgets/meter/: lv_meter.c
    ../Middlewares/LVGL/GUI/lvgl/src/extra/layouts/flex/: lv_flex.c
    ../Middlewares/LVGL/GUI/lvgl/src/extra/layouts/grid/: lv_grid.c
  group Middlewares/LVGL/GUI_Port
    ../Middlewares/LVGL/GUI/porting/: lv_port_disp.c
software components: CMSIS:CORE 4.3.0
